# Keil uVision project 4wd_robot.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 4wd_robot
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\COMMON;.\MCAL\gpio;.\MCAL\gpt;.\ECUAL\dc_motor;.\ECUAL\h_gpt;.\ECUAL\led;.\ECUAL\push_button;.\ECUAL\pwm;.\APPLICATION
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group gpio
    ./MCAL/gpio/: gpio_config.c gpio_config.h gpio_interface.h gpio_private.h gpio_prog.c
  group common
    ./COMMON/: bit_math.h std_types.h
  group gpt
    ./MCAL/gpt/: gpt_interface.h gpt_private.h gpt_program.c
  group main
    ./: main.c
  group led
    ./ECUAL/led/: led_config.c led_config.h led_interface.h led_prog.c
  group dcm
    ./ECUAL/dc_motor/: dc_motor_prog.c dcm_cfg.c dcm_cfg.h dcm_interface.h dcm_private.h
  group pwm
    ./ECUAL/pwm/: pwm_cfg.c pwm_cfg.h pwm_interface.h pwm_prog.c
  group push_button
    ./ECUAL/push_button/: push_button_cfg.c push_button_cfg.h push_button_interface.h push_button_prog.c
  group h_gpt
    ./ECUAL/h_gpt/: htimer_interface.h htimer_program.c
  group app
    ./APPLICATION/: app.c app.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
