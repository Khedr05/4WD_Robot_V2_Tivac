# Keil uVision project 4WD.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 4WD
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\APPLICATION;.\COMMON;.\MCAL\gpio;.\MCAL\gpt;.\ECUAL\dc_motor;.\ECUAL\h_gpt;.\ECUAL\led;.\ECUAL\push_button;.\ECUAL\pwm
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./APPLICATION/: app.c app.h
  group gpio
    ./MCAL/gpio/: gpio_config.c gpio_prog.c gpio_config.h gpio_interface.h gpio_private.h
  group led
    ./ECUAL/led/: led_config.c led_prog.c led_config.h led_interface.h
  group pwm
    ./ECUAL/pwm/: pwm_prog.c
  group h_gpt
    ./ECUAL/h_gpt/: h_gpt_prog.c
  group gpt
    ./MCAL/gpt/: gpt_config.h
  group dc_motor
    ./ECUAL/dc_motor/: dc_motor_prog.c
  group push_button
    ./ECUAL/push_button/: push_button_prog.c
  group common
    ./COMMON/: bit_math.h std_types.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
